# Keil uVision project ADC.uvprojx, settings and files
target ADC (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ADC +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\CORE;..\USER;..\OBJ;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USMART;..\HALLIB\STM32F1xx_HAL_Driver\Inc;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\ADC;..\DSPLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f1xx_it.c system_stm32f1xx.c stm32f1xx_hal_msp.c AD9833.c AD9833.h AD98332.c AD98332.h key.c key.h
  group CORE
    ../CORE/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h core_cm3.h startup_stm32f103xe.s
  group HALLIB
    ../HALLIB/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_dma.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/ADC/: adc.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group README
    ../: readme.txt
  group DSPLIB
    ../DSPLIB/: cr4_fft_256_stm32.s cr4_fft_1024_stm32.s stm32_dsp.h table_fft.h
software components: CMSIS:CORE 5.0.1, CMSIS:DSP 1.5.1
